# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\System;.\Hardware;.\PID;.\User;.\System;.\Hardware\Encoder;.\Hardware\Key;.\Hardware\led;.\Hardware\mithon;.\Hardware\Motor;.\Hardware\MotorRun;.\Hardware\OLED;.\Hardware\pid;.\Hardware\PWM;.\Hardware\Serial;.\Hardware\Timer;.\Hardware\UART2;.\User\sys;.\System\APP;.\System\delay;.\System\wit_c_sdk;.\Hardware\Servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: REG.h
    ./System/APP/: APP.c
    ./System/delay/: delay.c
    ./System/wit_c_sdk/: wit_c_sdk.c
  group Hardware
    ./Hardware/Encoder/: Encoder.c
    ./Hardware/Key/: Key.c
    ./Hardware/led/: led.c
    ./Hardware/mithon/: mithon.c
    ./Hardware/Motor/: Motor.c
    ./Hardware/MotorRun/: MotorRun.c
    ./Hardware/OLED/: OLED.c
    ./Hardware/pid/: pid.c
    ./Hardware/PWM/: PWM.c
    ./Hardware/Serial/: Serial.c
    ./Hardware/Timer/: Timer.c
    ./Hardware/UART2/: UART2.c
    ./Hardware/Servo/: Servo.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ./User/sys/: sys.c sys.h
